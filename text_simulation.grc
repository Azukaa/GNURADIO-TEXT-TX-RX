options:
  parameters:
    author: zuks
    generate_options: qt_gui
    id: text_simulation
    output_language: python
    title: TEXT TXRX
  states: {}

blocks:
- name: FB
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: M
  id: variable
  parameters:
    value: 2**bps
  states: {}
- name: alpha
  id: variable
  parameters:
    value: '0.2'
  states: {}
- name: b_eds
  id: variable
  parameters:
    value: '0'
  states: {}
- name: bps
  id: variable
  parameters:
    value: '1'
  states: {}
- name: delay
  id: variable
  parameters:
    value: '0'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '1'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '2'
    value: '0'
  states: {}
- name: polarity
  id: variable_qtgui_chooser
  parameters:
    label0: unipolar
    label1: polar
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '1'
    widget: radio_buttons
  states: {}
- name: pttaps
  id: variable
  parameters:
    value: pam.pamampt(sps,ptype,[tail_len,alpha])
  states: {}
- name: pttaps2
  id: variable
  parameters:
    value: pam.pamhRt(sps,ptype,[tail_len,alpha])
  states: {}
- name: ptype
  id: variable
  parameters:
    value: '"rrcf"'
  states: {state: disabled}
- name: ptype
  id: variable_qtgui_chooser
  parameters:
    label0: rect
    label1: tri
    label2: sinc
    label3: rcf
    label4: rrcf
    num_opts: '5'
    option0: rect
    option1: tri
    option2: sinc
    option3: rcf
    option4: rrcf
    type: string
    value: rect
    widget: radio_buttons
  states: {}
- name: samp_dly
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '20'
    value: '0'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 320e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: '10'
  states: {}
- name: sym_delay
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-8'
    step: '1'
    stop: '8'
    value: '0'
  states: {state: disabled}
- name: tag
  id: variable_tag_object
  parameters:
    key: pmt.intern("Z")
    offset: '0'
    src: pmt.intern("Vsrc")
    value: pmt.intern("0x5a")
  states: {}
- name: tail_len
  id: variable
  parameters:
    value: '5'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: noise
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-polarity*(M-1)+(1-polarity)*0'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: polarity*(M-1)+(1-polarity)*0
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_and_const_xx_0
  id: blocks_and_const_xx
  parameters:
    const: '255'
    type: byte
  states: {}
- name: blocks_and_const_xx_0_0
  id: blocks_and_const_xx
  parameters:
    const: '255'
    type: byte
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: polarity*0.5+(1-polarity)*1
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: delay
    type: float
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: delay
    type: byte
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /dev/pts/1
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /dev/pts/0
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: polarity*0.5+(1-polarity)*1
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain
    type: float
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: bps
    endianness: b_eds
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: bps
    endianness: b_eds
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: '[tag]'
    type: byte
    vector: list(ord(i) for i in "Zombie")
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: pttaps2
    type: fff
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: sps
    taps: '1'
    type: fff
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: pttaps
    type: fff
  states: {}
- name: pam
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\n\n# this module will be imported in the into your flowgraph\nimport numpy as np\ndef pamampt(sps, ptype, pparms= []):\n    if ptype == \"rect\":\n        nn = np.arange(sps)\n        pt = np.ones(len(nn))\n\n    elif ptype == 'tri':\n        nn = np.arange(-sps, sps)\n        pt = 1 + nn/float(sps)\n        ix = np.where(nn>=0)[0]\n        pt[ix] = 1 - nn[ix]/float(sps)\n\n    elif ptype == 'sinc':\n        k = 5 # default k\n        if len(pparms) > 0:\n            k = pparms[0]\n        nk = round(k*sps)\n        nn = np.arange(-nk, nk)\n        pt = np.sinc(nn/float(sps))\n        if len(pparms) > 1:\n            pt = pt * np.kaiser(len(pt), pparms[1])\n\n    elif ptype=='rrcf':\n        # Root raised cosine in freq\n        nk = round(pparms[0]*sps)\n        nn = np.arange(-nk,nk)\n        alfa = pparms[1]\n        # Rolloff parameter\n        atFB = pparms[1]/float(sps)*nn\n        atFB2 = np.power(4*atFB,2.0)\n        falf =  4*alfa/float(sps) #4*alfa*FB\n        pt = (1-alfa+4*alfa/np.pi)*np.ones(len(nn))\n        ix = np.where(np.logical_and(nn!=0,atFB2!=1.0))[0]\n        pt[ix] = np.sin((1-alfa)*np.pi/float(sps)*nn[ix])\n        pt[ix] = pt[ix]+falf*nn[ix]*np.cos((1+alfa)*np.pi/float(sps)*nn[ix])\n        pt[ix] = float(sps)/(np.pi)*pt[ix]/((1-np.power(falf*nn[ix],2.0))*nn[ix])\n        ix = np.where(atFB2 == 1.0)[0]\n        pt[ix] = (1+2/np.pi)*np.sin(np.pi/(4*alfa))+(1-2/np.pi)*np.cos(np.pi/(4*alfa))\n        pt[ix] = alfa/np.sqrt(2.0)*pt[ix]\n            \n    elif ptype == \"rcf\":\n        nk = round(pparms[0]*sps)\n        nn = np.arange(-nk,nk)\n        pt = np.sinc(nn/float(sps))\n        if len(pparms) > 1:\n            p2t = 0.25 * np.pi*np.ones(len(nn))\n            atFB = pparms[1]/float(sps)*nn\n            atFB2 = np.power(2*atFB,2.0)\n            ix = np.where(atFB2 != 1) [0]\n            p2t[ix] = np.cos(np.pi*atFB[ix])\n            p2t[ix] = p2t[ix]/(1-atFB2[ix])\n            pt = pt*p2t\n        else:\n            pt = np.ones(1) # Default value\n    return pt\n\n    \n\ndef pamhRt(sps,ptype,pparms = []):\n    pt = pamampt(sps,ptype,pparms)\n    hRt = pt[::-1]  # h_R(t) = p(-t)\n    hRt = 1.0/sum(np.power(pt,2.0)) * hRt\n    return hRt\n\n\n\n\n\n\n"
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"TX_FD"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"RX_FD"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"RX_FD_Filtered"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"RX_FD"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    marker1: '0'
    name: '"TX_TD"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    marker1: '0'
    name: '"RX_TD"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    marker1: '0'
    name: '"RX_TD"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_throttle_0, '0']
- [blocks_add_const_vxx_0_0, '0', blocks_float_to_char_0, '0']
- [blocks_add_xx_0, '0', fir_filter_xxx_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_and_const_xx_0, '0', blocks_file_sink_0_0, '0']
- [blocks_and_const_xx_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_and_const_xx_0_0, '0', blocks_file_sink_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_delay_0_0, '0', fir_filter_xxx_1, '0']
- [blocks_delay_0_1, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_float_to_char_0, '0', blocks_delay_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_char_to_float_0, '0']
- [blocks_throttle_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_and_const_xx_0_0, '0']
- [blocks_vector_source_x_0, '0', blocks_and_const_xx_0, '0']
- [fir_filter_xxx_0_0, '0', blocks_delay_0_0, '0']
- [fir_filter_xxx_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [fir_filter_xxx_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [fir_filter_xxx_1, '0', blocks_multiply_const_vxx_0, '0']
- [fir_filter_xxx_1, '0', qtgui_freq_sink_x_0_0_0_0, '0']
- [fir_filter_xxx_1, '0', qtgui_time_sink_x_0_0_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
